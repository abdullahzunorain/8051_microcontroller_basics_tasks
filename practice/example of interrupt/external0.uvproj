# Keil uVision project external0.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032AH Intel
  cpu: IRAM(0 - 0xFF) CLOCK(12000000)
  output: external0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
