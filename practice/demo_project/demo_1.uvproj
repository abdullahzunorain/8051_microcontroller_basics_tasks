# Keil uVision project demo_1.uvproj, settings and files
target demo_Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: demo_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\demo_project
  group Source
    ./: STARTUP.A51 demo_01.c
